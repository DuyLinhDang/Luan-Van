# Keil uVision project usart_json.uvprojx, settings and files
target 06_usart_json (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 05_timer +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: ..\..\my_lib_std\src;..\..\my_lib_std\STM32F10x;..\..\my_lib_std\function_h;..\..\my_lib_std\CoreSupport;..\..\my_lib_std\function_h;..\..\my_lib_std\2_io;..\..\my_lib_std\1_delay;..\..\my_lib_std\6_PWM;..\..\my_lib_std\3_usart;..\..\my_lib_std\4_TIMER;.\libcjson;..\..\my_lib_std\3.1_Uart
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group scr
    ../../my_lib_std/src/: stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h system_stm32f10x.c
    ./: main.c
  group startup
    ../../my_lib_std/startup/arm/: startup_stm32f10x_md.s
  group function
    ../../my_lib_std/function_c/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c
  group core
    ../../my_lib_std/CoreSupport/: core_cm3.c
  group lib_user
    ../../my_lib_std/2_io/: io.c
    ../../my_lib_std/1_delay/: delay.c
    ../../my_lib_std/3_usart/: usart.c
  group libcjson
    ./libcjson/: cJSON.c cJSON.h
